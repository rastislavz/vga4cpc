File: kicad/vga4cpc.kicad_sch (KiCad schematic)
At the start: 0 parts

Commit message: Rotated
Other:
- sheet Connectors ports: added +5V; removed none
- sheet Pico ports: added +5V; removed none
